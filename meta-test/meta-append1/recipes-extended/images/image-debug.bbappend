require append-image.inc
