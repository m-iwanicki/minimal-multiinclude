require append2-image.inc
